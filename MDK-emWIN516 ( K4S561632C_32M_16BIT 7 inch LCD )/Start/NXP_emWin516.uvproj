# Keil uVision project NXP_emWin516.uvproj, settings and files
target Debug_FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: EMWIN516
  c flags: Optim=1 OneElfS=1
  c define: DEBUG=1
  c include: .\Application;.\BoardSupport;.\Config;.\Core\CM3\CoreSupport;.\Core\CM3\DeviceSupport\NXP\LPC177x_8x;.\Drivers\include;.\Setup;.\Inc;.\GUI;.\GLCD;.\SDRAM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Setup\FLASH.sct
  link misc: --diag_suppress=6329 --diag_suppress=6314
  group Application
    ./Application/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c IMAGE_SeggerLogo_300x150_565c.c SEGGERDEMO.c
  group Config
    ./Config/: Global.h GUIConf.h SysConf.h
  group GUI
    ./GUI/: GUI.h emWin_516_Keil4_M3_LE.lib GUI_X.c
  group Inc
    ./Inc/: BSP.h JLINKMEM.h SEGGER.h TaskPrio.h
  group Setup
    ./Setup/: BSP.c GUIConf.c LCDConf.c LCDConf.h
    ./BoardSupport/: Cursor.c
  group Doc
    ./: ReadMe.txt
  group CMSIS_M3
    ./Core/CM3/CoreSupport/: core_cm3.c
    ./Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
  group Dirve
    ./Drivers/source/: lpc177x_8x_clkpwr.c lpc177x_8x_gpio.c lpc177x_8x_systick.c lpc177x_8x_pinsel.c
  group Startup
    ./Setup/: startup_LPC177x_8x.s
  group GLCD
    ./GLCD/: AsciiLib.c GLCD.c
  group SDRAM
    ./SDRAM/: SDRAM_K4M563233G_32M_32BIT.c SDRAM_K4S561632C_32M_16BIT.c
target Release_FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Start_LPC1788_EA_LPC1788_KEIL_CMSIS
  c flags: Optim=4 oTime=1
  c misc: --diag_suppress=951
  c include: Application;Config;GUI;Inc;Setup;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Setup\FLASH.sct
  link misc: --diag_suppress=6329 --diag_suppress=6314
