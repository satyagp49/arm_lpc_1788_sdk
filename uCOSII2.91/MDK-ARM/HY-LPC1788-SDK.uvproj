# Keil uVision project HY-LPC1788-SDK.uvproj, settings and files
target HY-LPC1788-SDK (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: HY-LPC1788-SDK +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\USER;..\USER\ucCos_App;..\USER\uCOS-VIEW;..\USER\uCOS-II;..\USER\uC-CPU;..\USER\lwip-1.3.2;..\USER\lwip-1.3.2\src;..\USER\lwip-1.3.2\src\api;..\USER\lwip-1.3.2\src\netif;..\USER\lwip-1.3.2\src\core;..\USER\lwip-1.3.2\src\arch;..\USER\lwip-1.3.2\src\include;..\USER\lwip-1.3.2\src\core\ipv4;..\USER\lwip-1.3.2\src\include\lwip;..\USER\lwip-1.3.2\src\include\netif;..\USER\lwip-1.3.2\src\include\arch;..\USER\lwip-1.3.2\src\include\ipv4\lwip;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Drivers\include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\CMSIS\Include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\Device\NXP\LPC177x_8x\Include;..\USER\PHYLAN
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../USER/: main.c
    ../USER/ucCos_App/: uctsk_Blink.c app_cfg.h includes.h
  group lpc177x.lpc178x.cmsis.driver.library_2012.8.13
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_gpio.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c lpc177x_8x_emac.c
  group CMSIS
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Startup
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group uC-OS-II/Port
    ../USER/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-OS-II/Source
    ../USER/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Config
    ../USER/ucCos_App/: OS_AppHooks.c os_cfg.h
  group Doc
    ../: readme.txt
