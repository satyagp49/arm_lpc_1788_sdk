# Keil uVision project Mci_FATFS.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Mci_FATFs +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\FatFs;..\..\Mci_FS;..\main;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Drivers\include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\CMSIS\Include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\Device\NXP\LPC177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_emc.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c lpc177x_8x_pinsel.c lpc177x_8x_rtc.c lpc177x_8x_uart.c lpc177x_8x_mci.c
  group Main
    ../main/: fs_mci.c monitor.c fatfs_main.c
  group Readme
    ../: fatfs_abstract.txt
  group FATFs
    ../FatFs/: ff.c
    ../FatFs/option/: ccsbcs.c
