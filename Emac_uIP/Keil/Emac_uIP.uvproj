# Keil uVision project Emac_uIP.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c include: ..\apps\webserver;..\lpc177x_8x_port;..\uip;..\apps;..\common;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\CMSIS\Include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\Device\NXP\LPC177x_8x\Include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Drivers\include;..\PHYLAN
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Core Files
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group Driver Files
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_gpio.c lpc177x_8x_pinsel.c lpc177x_8x_nvic.c lpc177x_8x_uart.c lpc177x_8x_emac.c
    ../PHYLAN/: phylan.c
  group Readme
    ../: abstract.txt
  group port
    ../lpc177x_8x_port/: clock-arch.c emac.c Emac_uIP.c
  group Common
    ../common/: Serial.c
  group uIP
    ../uip/: uip_arp.c psock.c timer.c uip.c
  group Webserver
    ../apps/webserver/: httpd-cgi.c httpd-fs.c http-strings.c httpd.c
