# Keil uVision project Project.uvproj, settings and files
target HY-LPC1788-SDK (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\USER\SDRAM;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\CMSIS\Include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\Device\NXP\LPC177x_8x\Include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../USER/: main.c
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Drivers/include/: debug_frmwrk.h
  group SDRAM
    ../USER/SDRAM/: SDRAM_K4M563233G_32M_32BIT.c SDRAM_K4S561632C_32M_16BIT.c
  group lpc177x.lpc178x.cmsis.driver.library_2012.8.13
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_emc.c lpc177x_8x_gpio.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c
  group CMSIS-CM3
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Startup
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group Doc
    ../: readme.txt
